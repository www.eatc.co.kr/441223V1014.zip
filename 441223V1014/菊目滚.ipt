# Autodesk Inventor part: 앞커버
## iProperties
Created: 2013-02
Part Number: 앞커버
Document SubType Name: Modeling
Designer: 한국산업디자인학원[gmhk.co.kr]
Density: 1 g/cm^3
Author: 한국산업디자인학원[gmhk.co.kr]
