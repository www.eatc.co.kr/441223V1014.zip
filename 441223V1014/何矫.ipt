# Autodesk Inventor part: 부시
## iProperties
Created: 2011-04
Part Number: 부시
Document SubType Name: Modeling
Designer: 한국산업디자인학원 [http://gmhk.co.kr]
Density: 1 g/cm^3
Author: pww
